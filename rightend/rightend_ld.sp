** HSPICE file for rightend_ld
**   - generated by ext2sp v4.1

** Include netlist file for rightend_ld
.include rightend_ld.spice

** Default 3.3V Power Supply
Vsupply Vdd GND 3.3V

** Specify input signals here
** e.g. for inputs A and B
VScan Scan GND PWL(0NS 0V  2NS 0V  2.25NS 3.3V  6NS 3.3V  6.25NS 0V)
** VB B GND PWL(0NS 0V  4NS 0V  4.25NS 3.3V  8NS 3.3V  8.25NS 0V)

** Default Simulation - Type, Resolution & Duration
.TRAN 10PS 10NS

** Specify ouput signals to measure here
** e.g. rise and fall delays for output Y
.measure tran scan_fall_delay TRIG v(Scan) VAL='3.3*0.5' TD=0NS RISE=1
+ TARG v(nScan) VAL='3.3*0.5' TD=0NS FALL=1
.measure tran scan_rise_delay TRIG v(Scan) VAL='3.3*0.5' TD=0NS FALL=1
+ TARG v(nScan) VAL='3.3*0.5' TD=0NS RISE=1

** Save results for display
.OPTIONS POST
** Avoid DC convergence in at unreasonable voltage
.OPTIONS GMINDC=1n

.END
