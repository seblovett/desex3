** HSPICE file for leftbuf
**   - generated by ext2sp v4.1

** Include netlist file for leftbuf
.include leftbuf.spice

** Default 3.3V Power Supply
Vsupply Vdd GND 3.3V

** Specify input signals here
** e.g. for inputs A and B
   VClock Clock   GND PWL(0NS 0V  2NS 0V  2.25NS 3.3V  10NS 3.3V  10.25NS 0V)
   VnReset nReset GND PWL(0NS 0V  4NS 0V  4.25NS 3.3V  12NS 3.3V  12.25NS 0V)
   VSDO   nSDO    GND PWL(0NS 0V  6NS 0V  6.25NS 3.3V  14NS 3.3V  14.25NS 0V)
   VTest  Test    GND PWL(0NS 0V  8NS 0V  8.25NS 3.3V  16NS 3.3V  16.25NS 0V)

** Default Simulation - Type, Resolution & Duration
.TRAN 10PS 20NS

** Specify ouput signals to measure here
** e.g. rise and fall delays for output Y
**   .measure tran fall_delay TRIG v(Y) VAL='3.3*0.9' TD=0NS FALL=1
**   + TARG v(Y) VAL='3.3*0.1' TD=0NS FALL=1
**   .measure tran rise_delay TRIG v(Y) VAL='3.3*0.1' TD=0NS RISE=1
**   + TARG v(Y) VAL='3.3*0.9' TD=0NS RISE=1

** Save results for display
.OPTIONS POST
** Avoid DC convergence in at unreasonable voltage
.OPTIONS GMINDC=1n

.END
