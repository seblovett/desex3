** HSPICE file for leftbuf_ld
**   - generated by ext2sp v4.1

** Include netlist file for leftbuf_ld
.include leftbuf_ld.spice

** Default 3.3V Power Supply
Vsupply Vdd GND 3.3V

** Specify input signals here
** e.g. for inputs A and B
VnClock  nClock  GND PWL(0NS 3.3V  2NS 3.3V  2.25NS 0V  6NS  0V  6.25NS  3.3V)
VnTest   nTest   GND PWL(0NS 3.3V  4NS 3.3V  4.25NS 0V  8NS  0V  8.25NS  3.3V)
VnnReset nnReset GND PWL(0NS 3.3V  6NS 3.3V  6.25NS 0V  10NS 0V  10.25NS 3.3V)
VnnSDO   nnSDO   GND PWL(0NS 3.3V  8NS 3.3V  8.25NS 0V  12NS 0V  12.25NS 3.3V)

** Default Simulation - Type, Resolution & Duration
.TRAN 10PS 15NS

** Specify ouput signals to measure here
** e.g. rise and fall delays for output Y
.measure tran x_clock_rise_prop_delay
+ TRIG v(Clock)    VAL='3.3*0.5' TD=0NS RISE=1
+ TARG v(ClockOut) VAL='3.3*0.5' TD=0NS RISE=1

.measure tran x_clock_fall_prop_delay
+ TRIG v(Clock)    VAL='3.3*0.5' TD=0NS FALL=1
+ TARG v(ClockOut) VAL='3.3*0.5' TD=0NS FALL=1

.measure tran x_test_rise_prop_delay
+ TRIG v(Test)    VAL='3.3*0.5' TD=0NS RISE=1
+ TARG v(TestOut) VAL='3.3*0.5' TD=0NS RISE=1

.measure tran x_test_fall_prop_delay
+ TRIG v(Test)    VAL='3.3*0.5' TD=0NS FALL=1
+ TARG v(TestOut) VAL='3.3*0.5' TD=0NS FALL=1

.measure tran x_nreset_rise_prop_delay
+ TRIG v(nReset)    VAL='3.3*0.5' TD=0NS RISE=1
+ TARG v(nResetOut) VAL='3.3*0.5' TD=0NS RISE=1

.measure tran x_nreset_fall_prop_delay
+ TRIG v(nReset)    VAL='3.3*0.5' TD=0NS FALL=1
+ TARG v(nResetOut) VAL='3.3*0.5' TD=0NS FALL=1

.measure tran x_sdo_rise_prop_delay
+ TRIG v(nSDO)    VAL='3.3*0.5' TD=0NS RISE=1
+ TARG v(SDO)     VAL='3.3*0.5' TD=0NS FALL=1

.measure tran x_sdo_fall_prop_delay
+ TRIG v(nSDO)    VAL='3.3*0.5' TD=0NS FALL=1
+ TARG v(SDO)     VAL='3.3*0.5' TD=0NS RISE=1

.measure Clock_to_ClockOut PARAM = '(x_clock_rise_prop_delay + x_clock_fall_prop_delay)/2'
.measure Test_to_TestOut PARAM = '(x_test_rise_prop_delay + x_test_fall_prop_delay)/2'
.measure nReset_to_nResetOut PARAM = '(x_nreset_rise_prop_delay + x_nreset_fall_prop_delay)/2'
.measure nSDO_to_SDO PARAM = '(x_sdo_rise_prop_delay + x_sdo_fall_prop_delay)/2'

** Save results for display
.OPTIONS POST
** Avoid DC convergence in at unreasonable voltage
.OPTIONS GMINDC=1n

.END
