** HSPICE file for nor2_ld
**   - generated by ext2sp v4.1

** Include netlist file for nor2_ld
.include nor2_ld.spice

** Default 3.3V Power Supply
Vsupply Vdd GND 3.3V

** Specify input signals here
** e.g. for inputs A and B
VNA NA GND PWL(0NS 3.3V  2NS 3.3V  2.25NS 0V  6NS 0V  6.25NS 3.3V)
VNB NB GND PWL(0NS 3.3V  8NS 3.3V  8.25NS 0V  12NS 0V  12.25NS 3.3V)

** Default Simulation - Type, Resolution & Duration
.TRAN 10PS 15NS

** Specify ouput signals to measure here
** e.g. rise and fall delays for output Y
.measure tran a_rise_prop_delay TRIG v(A) VAL='3.3*0.5' TD=0NS RISE=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS FALL=1
.measure tran a_fall_prop_delay TRIG v(A) VAL='3.3*0.5' TD=0NS FALL=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS RISE=1

.measure tran b_rise_prop_delay TRIG v(B) VAL='3.3*0.5' TD=0NS RISE=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS FALL=2
.measure tran b_fall_prop_delay TRIG v(B) VAL='3.3*0.5' TD=0NS FALL=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS RISE=2

** Save results for display
.OPTIONS POST
** Avoid DC convergence in at unreasonable voltage
.OPTIONS GMINDC=1n

.END
