** HSPICE file for fulladder_ld
**   - generated by ext2sp v4.1

** Include netlist file for fulladder_ld
.include halfadder_ld.spice

** Default 3.3V Power Supply
Vsupply Vdd GND 3.3V

** Specify input signals here
** e.g. for inputs A and B
VnA nA GND PWL(0NS 3.3V  3.75NS 3.3V  4NS 0V  7.75NS 0V  8NS 3.3V  11.75NS 3.3V  12NS  0V  13.75NS 0V  14NS  3.3V  17.75NS 3.3V  18NS 0V)
VnB nB GND PWL(0NS 3.3V  8.25NS 3.3V  8.5NS 0V  16.25NS 0V  16.5NS 0V  20.25NS 0V  20.5NS 3.3V  24.25NS 3.3V  24.5NS 0V)

** Default Simulation - Type, Resolution & Duration
.TRAN 10PS 30NS

** Specify ouput signals to measure here
.measure tran x_prop_delay_AS_1 TRIG v(A) VAL='3.3*0.5' TD=0NS RISE=1 TARG v(S) VAL='3.3*0.5' TD=0NS RISE=1
.measure tran x_prop_delay_BS_1 TRIG v(B) VAL='3.3*0.5' TD=0NS RISE=1 TARG v(S) VAL='3.3*0.5' TD=0NS RISE=2
.measure tran x_prop_delay_AS_0 TRIG v(A) VAL='3.3*0.5' TD=0NS FALL=2 TARG v(S) VAL='3.3*0.5' TD=0NS RISE=3
.measure tran x_prop_delay_BS_0 TRIG v(B) VAL='3.3*0.5' TD=0NS FALL=1 TARG v(S) VAL='3.3*0.5' TD=0NS RISE=4

.measure tran x_prop_delay_AC_1 TRIG v(A) VAL='3.3*0.5' TD=0NS RISE=2 TARG v(C) VAL='3.3*0.5' TD=0NS RISE=1
.measure tran x_prop_delay_BC_1 TRIG v(B) VAL='3.3*0.5' TD=0NS RISE=2 TARG v(C) VAL='3.3*0.5' TD=0NS RISE=3
.measure tran x_prop_delay_AC_0 TRIG v(A) VAL='3.3*0.5' TD=0NS FALL=2 TARG v(C) VAL='3.3*0.5' TD=0NS FALL=1
.measure tran x_prop_delay_BC_0 TRIG v(B) VAL='3.3*0.5' TD=0NS FALL=1 TARG v(C) VAL='3.3*0.5' TD=0NS FALL=2

.measure average_A_prop PARAM = '(x_prop_delay_AS_1 + x_prop_delay_AS_0 + x_prop_delay_AC_1 + x_prop_delay_AC_0)/4'
.measure average_B_prop PARAM = '(x_prop_delay_BS_1 + x_prop_delay_BS_0 + x_prop_delay_BC_1 + x_prop_delay_BC_0)/4'

** Save results for display
.OPTIONS POST
** Avoid DC convergence in at unreasonable voltage
.OPTIONS GMINDC=1n

.END
