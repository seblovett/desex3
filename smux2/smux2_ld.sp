** HSPICE file for smux2_ld
**   - generated by ext2sp v4.1

** Include netlist file for smux2_ld
.include smux2_ld.spice

** Default 3.3V Power Supply
Vsupply Vdd GND 3.3V

** Specify input signals here DONT LEAVE BLANK SPACES
   VNTEST NTEST GND PWL(0NS 0V  10NS 0V  10.25NS 3.3V  20NS 3.3V  24NS 3.3V  24.24NS 0V  28NS 0V  28.25NS 3.3V  38NS 3.3V  38.25NS 0V  42NS 0V  42.25NS 3.3V)
   VNSDI NSDI GND PWL(0NS 3.3V  4NS 3.3V  4.25NS 0V  8NS 0V  8.25NS 3.3V  20NS 3.3V  20.25NS 0V  30NS 0V  30.25NS 3.3V)
   VND ND GND PWL(0NS 3.3V  14NS 3.3V  14.25NS 0V  18NS 0V  18.24NS 3.3V  30NS 3.3V  34NS 3.3V  34.24NS 0V)

** Default Simulation - Type, Resolution & Duration
.TRAN 10PS 45NS

** Specify ouput signals to measure here
** e.g. rise and fall delays for output Y
   .measure tran x_SDI_Rise_Propagation_Delay TRIG v(SDI) VAL='3.3*0.5' TD=0NS RISE=1
   + TARG v(M) VAL='3.3*0.5' TD=0NS RISE=1
   .measure tran x_SDI_Fall_Propagation_Delay TRIG v(SDI) VAL='3.3*0.5' TD=0NS FALL=1
   + TARG v(M) VAL='3.3*0.5' TD=0NS FALL=1

   .measure tran x_D_Rise_Propagation_Delay TRIG v(D) VAL='3.3*0.5' TD=0NS RISE=1
   + TARG v(M) VAL='3.3*0.5' TD=0NS RISE=2
   .measure tran x_D_Fall_Propagation_Delay TRIG v(D) VAL='3.3*0.5' TD=0NS FALL=1
   + TARG v(M) VAL='3.3*0.5' TD=0NS FALL=2

   .measure tran x_Test_Pass_SDI_Rise_Propagation_Delay TRIG v(TEST) VAL='3.3*0.5' TD=0NS RISE=1
   + TARG v(M) VAL='3.3*0.5' TD=0NS RISE=3
   .measure tran x_Test_Pass_D_Fall_Propagation_Delay TRIG v(TEST) VAL='3.3*0.5' TD=0NS FALL=2
   + TARG v(M) VAL='3.3*0.5' TD=0NS FALL=3

   .measure tran x_Test_Pass_SDI_Fall_Propagation_Delay TRIG v(TEST) VAL='3.3*0.5' TD=0NS RISE=2
   + TARG v(M) VAL='3.3*0.5' TD=0NS FALL=4
   .measure tran x_Test_Pass_D_Rise_Propagation_Delay TRIG v(TEST) VAL='3.3*0.5' TD=0NS FALL=3
   + TARG v(M) VAL='3.3*0.5' TD=0NS RISE=5

   .measure SDI_Propagation PARAM = '(x_SDI_Fall_Propagation_Delay + x_SDI_Rise_Propagation_Delay)/2'
   .measure D_Propagation PARAM = '(x_D_Fall_Propagation_Delay + x_D_Rise_Propagation_Delay)/2'
   .measure Test_Pass_SDI_Propagation PARAM = '(x_Test_Pass_SDI_Fall_Propagation_Delay + x_Test_Pass_SDI_Rise_Propagation_Delay)/2'
   .measure Test_Pass_D_Propagation PARAM = '(x_Test_Pass_D_Fall_Propagation_Delay + x_Test_Pass_D_Rise_Propagation_Delay)/2'

** Save results for display
.OPTIONS POST
** Avoid DC convergence in at unreasonable voltage
.OPTIONS GMINDC=1n

.END
