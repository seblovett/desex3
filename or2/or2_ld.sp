** HSPICE file for or2_ld
**   - generated by ext2sp v4.1

** Include netlist file for or2_ld
.include or2_ld.spice

** Default 3.3V Power Supply
Vsupply Vdd GND 3.3V

** Specify input signals here
** e.g. for inputs A and B
VNA NA GND PWL(0NS 3.3V  2NS 3.3V  2.25NS 0V  6NS 0V  6.25NS 3.3V)
VNB NB GND PWL(0NS 3.3V  8NS 3.3V  8.25NS 0V  10NS 0V  10.25NS 3.3V)

** Default Simulation - Type, Resolution & Duration
.TRAN 10PS 12NS

** Specify ouput signals to measure here
** e.g. rise and fall delays for output Y
.measure tran x_a_fall_delay TRIG v(A) VAL='3.3*0.5' TD=0NS FALL=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS FALL=1
.measure tran x_a_rise_delay TRIG v(A) VAL='3.3*0.5' TD=0NS RISE=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS RISE=1

.measure tran x_b_fall_delay TRIG v(B) VAL='3.3*0.5' TD=0NS FALL=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS FALL=2
.measure tran x_b_rise_delay TRIG v(B) VAL='3.3*0.5' TD=0NS RISE=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS RISE=2

.measure A_to_Y PARAM = '(x_a_fall_delay + x_a_rise_delay)/2'
.measure B_to_Y PARAM = '(x_b_fall_delay + x_b_rise_delay)/2'

** Save results for display
.OPTIONS POST
** Avoid DC convergence in at unreasonable voltage
.OPTIONS GMINDC=1n

.END
