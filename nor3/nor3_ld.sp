** HSPICE file for nor3_ld
**   - generated by ext2sp v4.1

** Include netlist file for nor3_ld
.include nor3_ld.spice

** Default 3.3V Power Supply
Vsupply Vdd GND 3.3V

** Specify input signals here
** e.g. for inputs A and B
VA A GND PWL(0NS 0V  2NS 0V  2.25NS 3.3V  6NS 3.3V  6.25NS 0V)
VB B GND PWL(0NS 0V  8NS 0V  8.25NS 3.3V  12NS 3.3V  12.25NS 0V)
VC C GND PWL(0NS 0V  14NS 0V  14.25NS 3.3V  18NS 3.3V  18.25NS 0V)
** Default Simulation - Type, Resolution & Duration
.TRAN 10PS 20NS

** Specify ouput signals to measure here
** e.g. rise and fall delays for output Y
**   .measure tran fall_delay TRIG v(Y) VAL='3.3*0.9' TD=0NS FALL=1
**   + TARG v(Y) VAL='3.3*0.1' TD=0NS FALL=1
**   .measure tran rise_delay TRIG v(Y) VAL='3.3*0.1' TD=0NS RISE=1
**   + TARG v(Y) VAL='3.3*0.9' TD=0NS RISE=1
.measure tran a_rise_prop_delay TRIG v(A) VAL='3.3*0.5' TD=0NS RISE=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS FALL=1
.measure tran a_fall_prop_delay TRIG v(A) VAL='3.3*0.5' TD=0NS FALL=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS RISE=1

.measure tran b_rise_prop_delay TRIG v(B) VAL='3.3*0.5' TD=0NS RISE=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS FALL=2
.measure tran b_fall_prop_delay TRIG v(B) VAL='3.3*0.5' TD=0NS FALL=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS RISE=2

.measure tran c_rise_prop_delay TRIG v(C) VAL='3.3*0.5' TD=0NS RISE=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS FALL=3
.measure tran c_fall_prop_delay TRIG v(C) VAL='3.3*0.5' TD=0NS FALL=1
+ TARG v(Y) VAL='3.3*0.5' TD=0NS RISE=3

** Save results for display
.OPTIONS POST
** Avoid DC convergence in at unreasonable voltage
.OPTIONS GMINDC=1n

.END
