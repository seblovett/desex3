** HSPICE file for nand2_ld
**   - generated by ext2sp v4.1

** Include netlist file for nand2_ld
.include nand2_ld.spice

** Default 3.3V Power Supply
Vsupply Vdd GND 3.3V

** Specify input signals here
** e.g. for inputs A and B
   VNA NA GND PWL(0NS 0V  2NS 0V  2.25NS 3.3V  6NS 3.3V  6.25NS 0V)
   VNB NB GND PWL(0NS 0V  10NS 0V  10.25NS 3.3V  14NS 3.3V  14.25NS 0V)

** Default Simulation - Type, Resolution & Duration
.TRAN 10PS 20NS
co
** Specify ouput signals to measure here
** e.g. rise and fall delays for output Y
   .measure tran x_A_Rise_Propagation_Delay TRIG v(A) VAL='3.3*0.5' TD=0NS FALL=1
   + TARG v(Y) VAL='3.3*0.5' TD=0NS RISE=1
   .measure tran x_A_Fall_Propagation_Delay TRIG v(A) VAL='3.3*0.5' TD=0NS RISE=1
   + TARG v(Y) VAL='3.3*0.5' TD=0NS FALL=1

   .measure tran x_B_Rise_Propagation_Delay TRIG v(B) VAL='3.3*0.5' TD=0NS FALL=1
   + TARG v(Y) VAL='3.3*0.5' TD=0NS RISE=2
   .measure tran x_B_Fall_Propagation_Delay TRIG v(B) VAL='3.3*0.5' TD=0NS RISE=1
   + TARG v(Y) VAL='3.3*0.5' TD=0NS FALL=2

   .measure A_to_Y PARAM = '(x_A_Fall_Propagation_Delay + x_A_Rise_Propagation_Delay)/2'
   .measure B_to_Y PARAM = '(x_B_Fall_Propagation_Delay + x_B_Rise_Propagation_Delay)/2'

** Save results for display
.OPTIONS POST
** Avoid DC convergence in at unreasonable voltage
.OPTIONS GMINDC=1n

.END
