** HSPICE file for rdtype_ld
**   - generated by ext2sp v4.1

** Include netlist file for rdtype_ld
.include rdtype_ld.spice

** Default 3.3V Power Supply
Vsupply Vdd GND 3.3V

** Specify input signals here
** e.g. for inputs A and B
   VA ND GND PWL(
      +0NS        0V
      +2NS        0V
      +2.25NS     3.3V
      +6NS        3.3V
      +6.25NS     0V
   +)
   VB NCLOCK GND PWL(
      +0NS        3.3V
      +1NS        3.3V
      +1.25NS     0V
      +2NS        0V
      +2.25NS     3.3V
      +3NS        3.3V
      +3.25NS     0V
      +4NS        0V
      +4.25NS     3.3V
      +5NS        3.3V
      +5.25NS     0V
      +6NS        0V
      +6.25NS     3.3V
      +7NS        3.3V
      +7.25NS     0V
      +8NS        0V
      +8.25NS     3.3V
      +9NS        3.3V
      +9.25NS     0V
      +10NS       0V
   +)
   VC NNRESET GND PWL(
      +0NS        0V
      +9NS        0V
      +9.25NS     3.3V
      +10NS       3.3V
   +)

** Default Simulation - Type, Resolution & Duration
.TRAN 10PS 12NS

** Specify ouput signals to measure here
** e.g. rise and fall delays for output Y
**   .measure tran fall_delay TRIG v(Y) VAL='3.3*0.9' TD=0NS FALL=1
**   + TARG v(Y) VAL='3.3*0.1' TD=0NS FALL=1
**   .measure tran rise_delay TRIG v(Y) VAL='3.3*0.1' TD=0NS RISE=1
**   + TARG v(Y) VAL='3.3*0.9' TD=0NS RISE=1

** Save results for display
.OPTIONS POST
** Avoid DC convergence in at unreasonable voltage
.OPTIONS GMINDC=1n

.END
