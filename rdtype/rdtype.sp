** HSPICE file for rdtype
**   - generated by ext2sp v4.1

** Include netlist file for rdtype
.include rdtype.spice

** Default 3.3V Power Supply
Vsupply Vdd GND 3.3V

**************************
**     Input signals    **
**************************

** Pulse reset active low at start of time
   VNRST    NRST GND PWL(
      +0NS     3.3V
      +2NS     0V
      +20NS    3.3V
   +)

** I/P pattern -> 1 0 1 0 1 1 0 0 1 1
   VD       D GND PWL(
      +0NS     0V
      +25NS    3.3V
      +35NS    0V
      +45NS    3.3V
      +55NS    0V
      +65NS    3.3V
      +75NS    3.3V
      +85NS    0V
      +95NS    0V
      +105NS   3.3V
      +115NS   3.3V
   +)

** Clock with 10NS period
   VCLK     CLK GND PWL(
      +0NS     0V
      +30NS    3.3V
      +40NS    0V
      +50NS    3.3V
      +60NS    0V
      +70NS    3.3V
      +80NS    0V
      +90NS    3.3V
      +100NS   0V
      +110NS   3.3V
      +120NS   0V
   +)

** Default Simulation - Type, Resolution & Duration
.TRAN 10PS 130NS

** Save results for display
.OPTIONS POST
** Avoid DC convergence in at unreasonable voltage
.OPTIONS GMINDC=1n

.END
